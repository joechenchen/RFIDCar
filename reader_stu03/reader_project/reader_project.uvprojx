# Keil uVision project reader_project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: reader_project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51 BOOTLOADER
  c include: ..\drivers_nrf;..\my_drivers;..\Application;..\Application\user_inc;..\Application\sys;..\Application\usart_com;..\Application\update
  memory RVCT4: ROM 0x1a000 size 0x24800
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../Application/: main.c
    ../Application/usart_com/: common.c
    ../Application/user_src/: crc.c
  group nRF_Drivers
    ../drivers_nrf/: simple_uart.c nrf_nvmc.c
  group My_Drivers
    ../my_drivers/: radio_config.c tim.c
    ../Application/sys/: sys.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.7.1
